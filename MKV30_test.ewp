# IAR project MKV30_test.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV30F64xxx10 NXP MKV30F64xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MKV31F512VLL12; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; FRDM_KV31F; FREEDOM; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: board; CMSIS; component/lists; component/uart; device; drivers; utilities; lab
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: MKV30_test.srec
  ILINK.IlinkOutputFile: MKV30_test.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKV31F512xxx12 NXP MKV31F512xxx12
  ICCARM.CCDefines: NDEBUG; CPU_MKV31F512VLL12; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; FRDM_KV31F; FREEDOM; MCUXPRESSO_SDK
  ICCARM.CCIncludePath2: board; CMSIS; component/lists; component/uart; device; drivers; utilities
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  ILINK.IlinkIcfFile: MKV31F51212/iar/MKV31F512xxx12_flash.icf
  group (top)
    ./: ServoControl.mex
  group board
    board/: board.c board.h clock_config.c clock_config.h peripherals.c peripherals.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h
  group component/lists
    component/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/uart
    component/uart/: fsl_adapter_uart.c fsl_adapter_uart.h
  group device
    device/: fsl_device_registers.h MKV30F12810.h MKV30F12810_features.h system_MKV30F12810.c system_MKV30F12810.h
  group doc
    doc/: readme.txt
  group drivers
    drivers/: fsl_adc16.c fsl_adc16.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_dac.c fsl_dac.h fsl_ftm.c fsl_ftm.h fsl_gpio.c fsl_gpio.h fsl_lpuart.c fsl_lpuart.h fsl_pit.c fsl_pit.h fsl_port.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h fsl_vref.c fsl_vref.h
  group lab
    lab/: Lab_pwm.c Lab_pwm.h
  group MKV30F6410
    MKV30F6410/: MKV30F64xxx10.icf
  group source
    source/: pid.c ServoControl.c
  group startup
    startup/: startup_MKV30F12810.s
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_str.c fsl_str.h
